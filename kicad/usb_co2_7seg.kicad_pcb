# Repository urib0/usb_co2_7seg

File README.md:

# usb_co2_7seg

Mac, Linux マシンに USB で接続できて追加ドライバ不要で値を読める CO2 と 7 セグ表示器

## 使い方(macOS)

まず、USB 機器をすべてコンピュータから取り外す。

次に、usb_co2_7seg を USB ポートに接続する。

次に、コンピュータに接続されているシリアルポートの一覧を表示する。

```
$ ls -1 /dev/cu.*
/dev/cu.Bluetooth-Incoming-Port
/dev/cu.iMiminashi5s-WirelessiAP
/dev/cu.usbmodem14101
```

上記の例の場合、`cu.usbmodem14101` というデバイスファイルが usb_co2_7seg を示す。

次に、`stty`コマンドを実行してシリアルポートの設定を行う。

```sh
stty -f /dev/cu.usbmodem14101 raw 9600
```

最後に、`cat`コマンドでデバイスファイルを読み込むと CO2 の値(ppm)が表示される。

```
$ cat /dev/cu.usbmodem14101
co2=399;status=0
co2=399;status=0
co2=399;status=0
co2=399;status=0
co2=399;status=0
co2=399;status=0
```

## 使い方(Linux)

まず、USB 機器をすべてコンピュータから取り外す。

次に、usb_co2_7seg を USB ポートに接続する。

次に、コンピュータに接続されているシリアルポートの一覧を表示する。

```
$ ls -1 /dev/tty*
/dev/tty
.
. (中略)
.
/dev/ttyACM0
/dev/ttyAMA0
/dev/ttyprintk
/dev/ttyUSB0
```

上記の例の場合、`/dev/ttyACM0` というデバイスファイルが usb_co2_7seg を示す。

次に、`stty`コマンドを実行してシリアルポートの設定を行う。

```sh
stty -F /dev/ttyACM0 raw 9600
```

最後に、`cat`コマンドでデバイスファイルを読み込むと CO2 の値(ppm)が表示される。

```
$ cat /dev/ttyACM0
co2=399;status=0
co2=399;status=0
co2=399;status=0
co2=399;status=0
co2=399;status=0
```

## KiCad design kicad/usb_co2_7seg.kicad_pcb

Parts:
C1, C2: C; C_Disc_D5.0mm_W2.5mm_P5.00mm
D1: LED; LED_D3.0mm
R1, R2, R3, R4: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1, U2: PinHeader_XIAO
U3: SeeeduinoXIAO; SeeedXIAO
U4: MH-Z19B
U5: TM1637; TM1630
U6: 7segment_led; 7segment_led_0.56
U7: SW_push_2pin; SW_PUSH_2pin
U8: MH-Z14A

Connections:
+5V: C1.1, C2.1, R1.1, R2.1, R3.1, R4.1, U2.7, U3.14 (5V), U4.9 (Vin), U5.16 (VDD), U8.1
GND: C1.2, C2.2, D1.1 (K), U2.6, U3.13 (GND), U4.8 (GND), U5.1 (GND), U7.2, U8.3
unnamed: D1.2 (A), R2.2, U1.1, U3.1 (PA02_A0_D0)
unnamed: R1.2, U1.2, U3.2 (PA4_A1_D1), U7.1
unnamed: R3.2, U2.2, U3.9 (PA7_A8_D8_SCK), U5.17 (DIO)
unnamed: R4.2, U2.1, U3.8 (PB09_A7_D7_RX), U5.18 (CLK)
unnamed: U1.3, U3.3 (PA10_A2_D2), U4.1 (HD), U8.8
unnamed: U1.4, U3.4 (PA11_A3_D3), U4.3 (Tx), U8.19
unnamed: U1.5, U3.5 (PA8_A4_D4_SDA), U4.4 (Rx), U8.18
unnamed: U1.6, U3.6 (PA9_A5_D5_SCL)
unnamed: U1.7, U3.7 (PB08_A6_D6_TX)
unnamed: U2.3, U3.10 (PA5_A9_D9_MISO)
unnamed: U2.4, U3.11 (PA6_A10_D10_MOSI)
unnamed: U2.5, U3.12 (3V3)
unnamed: U5.2 (SEG1), U6.11 (A)
unnamed: U5.3 (SEG2), U6.7 (B)
unnamed: U5.4 (SEG3), U6.4 (C)
unnamed: U5.5 (SEG4), U6.2 (D)
unnamed: U5.6 (SEG5), U6.1 (E)
unnamed: U5.7 (SEG6), U6.10 (F)
unnamed: U5.8 (SEG7), U6.5 (G)
unnamed: U5.9 (SEG8), U6.3 (DP)
unnamed: U5.12 (GRID4), U6.6 (C4)
unnamed: U5.13 (GRID3), U6.8 (C3)
unnamed: U5.14 (GRID2), U6.9 (C2)
unnamed: U5.15 (GRID1), U6.12 (C1)

Board: 2 copper layers, 95.0 x 72.0 mm, 15 parts (0 on the bottom side), 26 nets.

## Commit log

2021-04-15 回路図をひいた
2021-05-04 ファイル名を修正
2021-05-04 配置だけした
2021-05-04 配線済み DRC ok
2021-05-04 プロットの設定を更新
2021-05-16 usb_7segからコピー
2021-05-16 とりあえず動く
2021-05-16 しきい値を超えたら警告のLEDを点灯するようにした
2021-05-17 外観写真を追加
2021-05-17 READMEを追加
2021-05-17 スタンドアロンでも使えるようシリアルの接続待ちをやめた
2021-05-17 内容を移行した
2021-05-17 フォーマッタをかけた
2021-05-17 誤記を修正
2021-05-23 基板に存在しないSW2を消してSW1を定義し直した
2021-05-23 初期化時に自動校正をOFFにするようにした
2021-05-23 ファイル名を変更
2021-05-23 SWの長押しチェックを追加
2021-05-23 メインループの周期を1msから10msに変更した
2021-05-23 ポーリングと周期処理でブロックを分けた
2021-05-23 変数の命名規則を統一
2021-05-23 7セグLEDに表示する処理を別関数にした
2021-05-23 CO2濃度のシリアル出力を別関数にした
2021-05-23 CO2値のシリアル出力と7セグLEDへの表示を周期処理に移した
2021-05-23 基板上の警告LEDを点灯する処理を別関数にした
2021-05-23 制御対象を引数にして明確化した
2021-05-23 fix typo
2021-06-13 MH-Z14Aに対応 ERC OK
2021-06-13 部品の仮置き
2021-06-13 MH-Z14Aの不要なピンを未接続にした
2021-06-13 配置配線完了 DRC OK
2021-06-13 ガーバー出力用の設定をした
